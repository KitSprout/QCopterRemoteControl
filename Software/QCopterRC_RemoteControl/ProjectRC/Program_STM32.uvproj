# Keil uVision project Program_STM32.uvproj, settings and files
target STM32F407VET (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F407VGT +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40XX, USE_STDPERIPH_DRIVER, __FPU_PRESENT=1, __FPU_USED =1, ARM_MATH_CM4, __CC_ARM
  c include: ..\;..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\Program_Dirver;..\Program_Algorithm;..\Program_Module;..\Fatfs;..\Program_System
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ../Libraries/CMSIS/: startup_stm32f40xx.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_dma.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_fsmc.c
    ../Program_Dirver/: stm32f4xx_conf.h
  group ArnMath
    ../Libraries/CMSIS/FastMathFunctions/: arm_sin_f32.c arm_cos_f32.c
  group Driver
    ../Program_Dirver/: stm32f4_system.c stm32f4_delay.c stm32f4_adc.c stm32f4_usart.c stm32f4_spi.c stm32f4_sdio.c
  group FatFs
    ../Fatfs/: ff.c diskio.c
  group Program
    ../Program_System/: QCopterRC.c QCopterRC_it.c QCopterRC_board.c QCopterRC_transport.c QCopterRC_window.c system_waveForm.c system_engine3D.c
  group Module
    ../Program_Module/: module_rs232.c module_nrf24l01.c module_r61581.c
  group Algorithm
    ../Program_Algorithm/: algorithm_string.c algorithm_bitmap.c algorithm_quaternion.c
